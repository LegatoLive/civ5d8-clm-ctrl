# Keil uVision project f103-spi.uvprojx, settings and files
target STM32F103RBT6 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: f103-spi
  c flags: Optim=4 uC99=1 v6Lang=1 v6LangP=1 wLevel=1
  c define: STM32F10X_MD, USE_STDPERIPH_DRIVER
  c include: .\CMSIS;.\Device;.\STM32F10x_StdPeriph_Driver\inc;.\STM32F10x_StdPeriph_Driver\src;.\User;.\User\m6775t-library;.\User\rtc
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Startup
    ./CMSIS/: startup_stm32f10x_md.s
  group CMSIS
    ./CMSIS/: core_cm3.c
  group Device
    ./Device/: system_stm32f10x.c stm32f10x.h stm32f10x_it.c
  group StdPeriph
    ./STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group User
    ./User/: main.c main.h
  group M6775T
    ./user/m6775t-library/: m6775t.c m6775t.h m6775t_fonts.c
  group RTC
    ./User/rtc/: rtc.c rtc.h
